# Keil uVision project HD-Vessel-Anchor.uvprojx, settings and files
target LwIP (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IRAM(0x20000000,0x00030000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: HD-Vessel-Anchor
  AfterMake: D:\tools\keil\ARM\ARMCC\bin\fromelf.exe --bin -o ..\output\HD-Vessel-Anchor.bin  ..\Output\HD-Vessel-Anchor.axf
  c flags: OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCO,USE_FULL_ASSERT
  c misc: --c99
  c include: ..\Libraries\CMSIS\Include;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_HAL_Driver\Inc;..\User;..\User\usart;..\User\led;..\FreeRTOS\include;..\FreeRTOS\port\RVDS\ARM_CM4F;..\LwIP\include;..\LwIP\include\compat;..\LwIP\include\lwip;..\LwIP\include\netif;..\LwIP\include\lwip\apps;..\LwIP\include\lwip\priv;..\LwIP\include\lwip\prot;..\User\arch;..\User\cm_backtrace;..\User\common;..\User\apptask;..\User\ServerToAnchor;..\User\public;..\User\RTC;..\User\AnchorToTag;..\User\queue;..\User\mymalloc;..\User\stmflash;..\User\Timer;..\User\spi;..\SX127X\HAL;..\SX127X\radio;..\SX127X\example;..\User\network;..\User\eeprom
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_HAL_Driver
    ../Libraries/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_eth.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_sdram.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rng.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_sram.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_usb.c
  group USER
    ../User/usart/: bsp_debug_usart.c
    ../User/led/: bsp_led.c
    ../User/eth/: bsp_eth.c
    ../User/common/: board.c main.c stm32f4xx_it.c udpecho.c
    ../User/apptask/: APPTask.c
    ../User/ServerToAnchor/: ServerToAnchor.c
    ../User/public/: public.c
    ../User/RTC/: rtc.c
    ../User/queue/: iacs_queue.c
    ../User/mymalloc/: malloc.c
    ../User/stmflash/: stmflash.c
    ../User/Timer/: time.c
    ../User/spi/: spi.c
    ../User/network/: network.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/RVDS/ARM_CM4F/: port.c
  group LwIP/api
    ../LwIP/api/: api_lib.c api_msg.c err.c if_api.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group LwIP/core
    ../LwIP/core/: altcp.c altcp_alloc.c altcp_tcp.c def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../LwIP/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
  group LwIP/netif
    ../LwIP/netif/: ethernet.c bridgeif.c lowpan6.c lowpan6_ble.c lowpan6_common.c zepif.c
  group LwIP/arch
    ../User/arch/: ethernetif.c sys_arch.c
  group cm_backtrace
    ../User/cm_backtrace/: cm_backtrace.c
    ../User/cm_backtrace/fault_handler/keil/: cmb_fault.S
  group sx127x
    ../SX127X/HAL/: SX127x_hal.c
    ../SX127X/radio/: sx127x_driver.c
    ../SX127X/example/: Lora_demo.c
  group eeprom
    ../User/eeprom/: bsp_i2c_ee.c
